Commit message: Add legs to table

File: script/screw_assembly/generated/workbench.urdf (robot description, URDF)
Before this commit: robot workbench, 1 links, 0 joints
Links:
- link top: geometry collision box size=0.05 0.05 0.36; collision box size=0.05 0.05 0.36
